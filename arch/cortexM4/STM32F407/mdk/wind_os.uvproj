# Keil uVision project wind_os.uvproj, settings and files
target wind_os (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wind_os +hex
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\board;..\driver;..\port;..\start;..\..\..\..\src\api;..\..\..\..\src\app;..\..\..\..\src\console\framework;..\..\..\..\src\core;..\..\..\..\src\driver;..\..\..\..\src\entry;..\..\..\..\src\lib;..\..\..\..\src\xlib;..\..\..\..\src\console\cmd
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start
    ../start/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group board
    ../board/: common.c common.h led.c led.h stm32f4xx_it.c stm32f4xx_it.h usart1.c usart1.h
  group driver
    ../driver/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group port
    ../port/: wind_config.h wind_os_hwif.c wind_os_hwif.h wind_types.h wind_os_switch.s
  group os_console_framework
    ../../../../src/console/framework/: console_framework.c console_framework.h wind_console.h wind_ctl_user.h wind_key.h
  group os_console_cmd
    ../../../../src/console/cmd/: cmd_echo.c cmd_help.c cmd_proc.c cmd_show.c cmd_stat.c cmd_test.c cmd_user.c
  group os_entry
    ../../../../src/entry/: user_entry.c user_hooks.c
  group os_lib
    ../../../../src/lib/: RBTree.c RBTree.h wind_assert.h wind_atomic.c wind_atomic.h wind_comman.c wind_comman.h wind_debug.c wind_debug.h wind_err.c wind_err.h wind_heap.c wind_heap.h wind_queue.c wind_queue.h wind_stack.c wind_stack.h wind_string.c wind_string.h wind_ticktimer.c wind_ticktimer.h
  group os_xlib
    ../../../../src/xlib/: crc16.c crc16.h crc32.c crc32.h fft.c fir.c firwin.c wind_macro.h
  group os_core
    ../../../../src/core/: wind_core.c wind_core.h wind_core_inc.h wind_flag.h wind_list.c wind_list.h wind_lock.c wind_lock.h wind_mem.c wind_mem.h wind_message.c wind_message.h wind_mpool.c wind_mpool.h wind_pipe.c wind_pipe.h wind_private_malloc.c wind_private_malloc.h wind_sem.c wind_sem.h wind_softint.c wind_softint.h wind_stat.c wind_stat.h wind_time.c wind_time.h wind_var.c wind_var.h wind_version.c wind_version.h wind_thread.c wind_thread.h
