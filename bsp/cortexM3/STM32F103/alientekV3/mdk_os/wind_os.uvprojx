# Keil uVision project wind_os.uvprojx, settings and files
target wind_os (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: wind_os +hex
  AfterMake: D:/Program Files/Keil_v5/ARM/ARMCC/bin/fromelf.exe --bin -o ./bin/wind_os.bin ./obj/wind_os.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,_USE_USER_PRINT,STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\board;..\..\driver;..\port;..\start;..\..\..\..\..\src\common;..\..\..\..\..\src\core;..\..\..\..\..\src\hal;..\..\..\..\..\src\lib;..\..\..\..\..\src\module\shell\framework;..\..\..\..\..\src\module\shell\cmd;..\..\..\..\..\src\module\cutest\framework;..\..\..\..\..\src\module\cutest\port;..\..\..\..\..\src\module\cutest\case;..\..\..\..\..\src\module\lua-5.3.4\src;..\..\..\..\..\src\module\vfs;..\..\..\..\..\src\module\vfs\treefs;..\..\..\..\..\src\module\vfs\listfs;..\..\..\..\..\src\module\db\framework
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  scatter file: .\wind_os.sct
  link misc: --entry Reset_Handler
  group start
    ../start/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
    ../start/startup/arm/: startup_stm32f10x_hd.s
  group board
    ../board/: beep.c beep.h led.c led.h sram.c sram.h usart.c usart.h
  group driver
    ../../driver/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group device
    ../device/: blkdev_null.c list_blkdev.c
  group common
    ../../../../../src/common/: wind_conv.c wind_conv.h wind_crc16.c wind_crc16.h wind_crc32.c wind_crc32.h wind_debug.c wind_debug.h wind_dlist.c wind_dlist.h wind_macro.h wind_queue.c wind_queue.h wind_string.c wind_string.h wind_tree.c wind_tree.h
  group os_port
    ../port/: wind_config.h wind_os_switch.s wind_std.c wind_std.h wind_os_prelunch.c wind_board_port.c wind_board_port.h wind_type.h
  group os_core
    ../../../../../src/core/: wind_core.c wind_core.h wind_pipe.c wind_pipe.h wind_sem.c wind_sem.h wind_thread.c wind_thread.h wind_time.c wind_time.h wind_timer.c wind_timer.h wind_msgbox.c wind_msgbox.h wind_mutex.c wind_mutex.h wind_pool.c wind_pool.h wind_heap.c wind_heap.h wind_softirq.c wind_softirq.h wind_event.c wind_event.h wind_stati.h wind_watchdog.c wind_watchdog.h wind_sysinfo.c wind_sysinfo.h wind_dbgpoint.c wind_dbgpoint.h wind_user.c wind_user.h wind_daemon.c wind_daemon.h wind_diagnose.c wind_diagnose.h wind_obj.c wind_obj.h wind_coroutine.c wind_coroutine.h
  group os_lib
    ../../../../../src/lib/: wind_stack.c wind_stack.h wind_atomic.c wind_atomic.h fft.c fir.c firwin.c wind_rbtree.c wind_rbtree.h
  group os_systhread
    ../../../../../src/systhread/: thread_daemon.c thread_idle.c thread_init.c thread_stati.c thread_timer.c thread_coroutine.c
  group os_hal
    ../../../../../src/hal/: wind_blkdev.c wind_blkdev.h wind_chdev.c wind_chdev.h
  group application
    ../../../../../src/application/alientekV3/: user_entry.c
  group component_vfs
    ../../../../../src/module/vfs/: adapter_treefs.c adapter_treefs.h wind_file.c wind_file.h wind_filepath.c wind_filepath.h wind_log.c wind_log.h wind_fs.c wind_fs.h
    ../../../../../src/module/vfs/treefs/: treefs.c treefs.h
    ../../../../../src/module/vfs/listfs/: listfs.c listfs.h listfs_bitmap.c listfs_bitmap.h
  group component_shell
    ../../../../../src/module/shell/framework/: cmd_history.c cmd_history.h shell_framework.c shell_framework.h wind_cmd.h wind_key.h
    ../../../../../src/module/shell/cmd/: cmd_beep.c cmd_blkdev.c cmd_cutest.c cmd_datetime.c cmd_echo.c cmd_fs.c cmd_led.c cmd_list.c cmd_lua.c cmd_mem.c cmd_reset.c cmd_stati.c cmd_sysinfo.c cmd_thread.c cmd_xmodem.c cmd_dbgpoint.c cmd_user.c cmd_watchdog.c cmd_diagnose.c shell_cmd_regif.c cmd_daemon.c
  group component_cutest
    ../../../../../src/module/cutest/port/: test_port.c test_port.h
    ../../../../../src/module/cutest/framework/: test_framework.c test_framework.h wind_cut.h
    ../../../../../src/module/cutest/testcase/: test_event.c test_heap.c test_msgbox.c test_mutex.c test_pipe.c test_pool.c test_queue.c test_sem.c test_softirq.c test_tree.c test_treefs.c test_fs.c test_listfsfs.c
