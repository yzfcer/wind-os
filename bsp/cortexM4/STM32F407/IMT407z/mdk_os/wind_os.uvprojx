# Keil uVision project wind_os.uvprojx, settings and files
target wind_os (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: wind_os +hex
  AfterMake: D:/Program Files/Keil_v5/ARM/ARMCC/bin/fromelf.exe --bin -o ./bin/wind_os.bin ./obj/wind_os.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,_USE_USER_PRINT,__USE_C99_MATH
  c include: ..\board;..\driver;..\port;..\start;..\..\..\..\..\src\api;..\..\..\..\..\src\application;..\..\..\..\..\src\common;..\..\..\..\..\src\core;..\..\..\..\..\src\driver;..\..\..\..\..\src\hal;..\..\..\..\..\src\lib;..\..\..\..\..\src\module\shell\framework;..\..\..\..\..\src\module\shell\cmd;..\..\..\..\..\src\module\cutest\framework;..\..\..\..\..\src\module\cutest\port;..\..\..\..\..\src\module\cutest\case;..\..\..\..\..\src\module\lua-5.3.4\src;..\..\..\..\..\src\module\vfs;..\..\..\..\..\src\module\vfs\treefs;..\..\..\..\..\src\module\vfs\listfs;..\..\..\..\..\src\module\db\framework
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\wind_os.sct
  link misc: --entry Reset_Handler
  group start
    ../start/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group board
    ../board/: common.c common.h led.c led.h stm32f4xx_it.c stm32f4xx_it.h usart1.c usart1.h beep.c beep.h spi.c spi.h w25qxx.c w25qxx.h 24c02.c 24c02.h
  group driver
    ../driver/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group device
    ../device/: dev_gpio.c blkdev_memblk.c blkdev_spi_flash.c blkdev_24c02.c dev_led.c list_blkdev.c list_dev.c dev_beep.c blkdev_null.c
  group common
    ../../../../../src/common/: wind_conv.c wind_conv.h wind_crc16.c wind_crc16.h wind_crc32.c wind_crc32.h wind_debug.c wind_debug.h wind_dlist.c wind_dlist.h wind_macro.h wind_queue.c wind_queue.h wind_string.c wind_string.h wind_tree.c wind_tree.h wind_xmodem.h wind_xmodem.c
  group os_port
    ../port/: wind_config.h wind_os_switch.s wind_std.c wind_std.h wind_type.h wind_os_prelunch.c wind_board_port.c wind_board_port.h
  group os_core
    ../../../../../src/core/: wind_core.c wind_core.h wind_pipe.c wind_pipe.h wind_sem.c wind_sem.h wind_thread.c wind_thread.h wind_time.c wind_time.h wind_timer.c wind_timer.h wind_msgbox.c wind_msgbox.h wind_mutex.c wind_mutex.h wind_pool.c wind_pool.h wind_heap.c wind_heap.h wind_softirq.c wind_softirq.h wind_watchdog.c wind_watchdog.h wind_event.c wind_event.h wind_sysinfo.c wind_sysinfo.h wind_dbgpoint.c wind_dbgpoint.h wind_user.c wind_user.h wind_daemon.c wind_daemon.h wind_diagnose.c wind_diagnose.h wind_obj.c wind_obj.h wind_coroutine.c wind_coroutine.h
  group os_lib
    ../../../../../src/lib/: wind_stack.c wind_stack.h wind_atomic.c wind_atomic.h fft.c fir.c firwin.c wind_rbtree.c wind_rbtree.h
  group os_systhread
    ../../../../../src/systhread/: thread_daemon.c thread_idle.c thread_init.c thread_stati.c thread_timer.c thread_coroutine.c
  group os_hal
    ../../../../../src/hal/: wind_blkdev.c wind_blkdev.h wind_chdev.c wind_chdev.h
  group application
    ../../../../../src/application/IMT407z/: led_app.c user_entry.c
  group component_vfs
    ../../../../../src/module/vfs/: adapter_treefs.c adapter_treefs.h wind_file.c wind_file.h wind_filepath.c wind_filepath.h wind_log.c wind_log.h wind_fs.c wind_fs.h
    ../../../../../src/module/vfs/treefs/: treefs.c treefs.h
    ../../../../../src/module/vfs/listfs/: listfs.c listfs.h listfs_bitmap.c listfs_bitmap.h listfs_fileinfo.c listfs_fileinfo.h
  group component_shell
    ../../../../../src/module/shell/framework/: cmd_history.c cmd_history.h shell_framework.c shell_framework.h wind_cmd.h wind_key.h
    ../../../../../src/module/shell/cmd/: cmd_beep.c cmd_blkdev.c cmd_cutest.c cmd_datetime.c cmd_echo.c cmd_fs.c cmd_led.c cmd_list.c cmd_lua.c cmd_mem.c cmd_reset.c cmd_stati.c cmd_sysinfo.c cmd_thread.c cmd_xmodem.c cmd_dbgpoint.c cmd_user.c cmd_watchdog.c cmd_diagnose.c shell_cmd_regif.c cmd_daemon.c
  group component_cutest
    ../../../../../src/module/cutest/framework/: test_framework.c test_framework.h wind_cut.h
    ../../../../../src/module/cutest/testcase/: test_event.c test_heap.c test_msgbox.c test_mutex.c test_pipe.c test_pool.c test_queue.c test_sem.c test_softirq.c test_tree.c test_treefs.c test_listfsfs.c cutest_register.c
  group component_lua
    ../../../../../src/module/lua-5.3.4/src/: lapi.c lapi.h lauxlib.c lauxlib.h lbaselib.c lbitlib.c lcode.c lcode.h lcorolib.c lctype.c lctype.h ldblib.c ldebug.c ldebug.h ldo.c ldo.h ldump.c lfunc.c lfunc.h lgc.c lgc.h linit.c liolib.c llex.c llex.h llimits.h lmathlib.c lmem.c lmem.h loadlib.c lobject.c lobject.h lopcodes.c lopcodes.h loslib.c lparser.c lparser.h lprefix.h lstate.c lstate.h lstring.c lstring.h lstrlib.c ltable.c ltable.h ltablib.c ltm.c ltm.h lua.c lua.h luaconf.h lualib.h lundump.c lundump.h lutf8lib.c lvm.c lvm.h lzio.c lzio.h
    ../../../../../src/module/lua-5.3.4/port/: lua_port.c
