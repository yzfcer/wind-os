# Keil uVision project wind_os.uvproj, settings and files
target wind_os (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: wind_os +hex
  AfterMake: C:/Keil_v5/ARM/ARMCC/bin/fromelf.exe --bin -o ./bin/wind_os.bin ./obj/wind_os.axf
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,_USE_USER_PRINT,STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\board;..\driver;..\port;..\start;..\..\..\..\..\src\api;..\..\..\..\..\src\app;..\..\..\..\..\src\common;..\..\..\..\..\src\console\framework;..\..\..\..\..\src\core;..\..\..\..\..\src\driver;..\..\..\..\..\src\entry;..\..\..\..\..\src\lib;..\..\..\..\..\src\xlib;..\..\..\..\..\src\console\cmd;..\..\..\..\..\src\test\framework;..\..\..\..\..\src\test\port;..\..\..\..\..\src\test\case;..\..\..\..\..\src\dev;..\..\..\..\..\src\components\lua-5.3.4\src;..\..\..\..\..\src\fs\treefs
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group start
    ../start/: core_cm3.c core_cm3.h stm32f10x.h stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h system_stm32f10x.c system_stm32f10x.h
    ../start/startup/arm/: startup_stm32f10x_hd.s
  group board
    ../board/: adc.c adc.h adxl345.c adxl345.h at24c02.c at24c02.h beep.c beep.h clock.c clock.h delay.c delay.h gy30.c gy30.h hwtimer.c hwtimer.h i2c.c i2c.h iwdg.c iwdg.h key.c key.h lcd1602.c lcd1602.h led.c led.h rtc.c rtc.h sht20.c sht20.h spi.c spi.h spilcd.c spilcd.h stmflash.c stmflash.h tcrt5000.c tcrt5000.h usart.c usart.h
  group driver
    ../driver/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group port
    ../port/: wind_config.h wind_os_hwif.c wind_os_hwif.h wind_types.h wind_os_switch.s wind_std.c wind_std.h
  group common
    ../../../../../src/common/: wind_conv.c wind_conv.h wind_crc16.c wind_crc16.h wind_crc32.c wind_crc32.h wind_debug.c wind_debug.h wind_dlist.c wind_dlist.h wind_macro.h wind_queue.c wind_queue.h wind_string.c wind_string.h wind_tree.c wind_tree.h
  group console_framework
    ../../../../../src/console/framework/: console_framework.c console_framework.h wind_console.h wind_ctl_user.h wind_key.h cmd_history.c cmd_history.h
  group console_cmd
    ../../../../../src/console/cmd/: cmd_list.c cmd_echo.c cmd_datetime.c cmd_mem.c cmd_user.c cmd_stati.c cmd_reset.c cmd_bee.c cmd_led.c cmd_blkdev.c cmd_lua.c cmd_treefs.c
  group console_port
    ../../../../../src/console/port/: console_port.c console_port.h
  group os_systhread
    ../../../../../src/systhread/: daemon_thread.c idle_thread.c init_thread.c stati_thread.c timer_thread.c
  group os_dev
    ../../../../../src/dev/: wind_dev.c wind_dev.h wind_blkdev.c wind_blkdev.h
  group os_entry
    ../../../../../src/entry/: user_entry.c led_app.c
  group os_lib
    ../../../../../src/lib/: RBTree.c RBTree.h wind_stack.c wind_stack.h wind_atomic.c wind_atomic.h
  group os_xlib
    ../../../../../src/xlib/: fft.c fir.c firwin.c
  group os_core
    ../../../../../src/core/: wind_core.c wind_core.h wind_pipe.c wind_pipe.h wind_sem.c wind_sem.h wind_thread.c wind_thread.h wind_time.c wind_time.h wind_var.c wind_var.h wind_version.c wind_version.h wind_timer.c wind_timer.h wind_msgbox.c wind_msgbox.h wind_mutex.c wind_mutex.h wind_pool.c wind_pool.h wind_heap.c wind_heap.h wind_softirq.c wind_softirq.h
  group test_framwwork
    ../../../../../src/test/framework/: cut.h test_framework.c test_framework.h cmd_test.c
  group test_port
    ../../../../../src/test/port/: test_port.c test_port.h
  group test_case
    ../../../../../src/test/testcase/: test_tree.c test_sem.c test_pipe.c test_queue.c test_msgbox.c test_mutex.c test_heap.c test_softirq.c test_pool.c
  group fs_treefs
    ../../../../../src/fs/treefs/: treefs.c treefs.h
