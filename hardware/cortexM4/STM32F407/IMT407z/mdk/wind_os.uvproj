# Keil uVision project wind_os.uvproj, settings and files
target wind_os (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: wind_os +hex
  AfterMake: C:/Keil_v5/ARM/ARMCC/bin/fromelf.exe --bin -o ./bin/wind_os.bin ./obj/wind_os.axf
  c flags: Optim=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,_USE_USER_PRINT,__USE_C99_MATH
  c include: ..\board;..\driver;..\port;..\start;..\..\..\..\..\src\api;..\..\..\..\..\src\app;..\..\..\..\..\src\common;..\..\..\..\..\src\console\framework;..\..\..\..\..\src\core;..\..\..\..\..\src\driver;..\..\..\..\..\src\entry;..\..\..\..\..\src\lib;..\..\..\..\..\src\xlib;..\..\..\..\..\src\console\cmd;..\..\..\..\..\src\test\framework;..\..\..\..\..\src\test\port;..\..\..\..\..\src\test\case;..\..\..\..\..\src\dev;..\..\..\..\..\src\components\lua-5.3.4\src;..\..\..\..\..\src\fs\treefs;..\..\..\..\..\src\components\xmodem
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group start
    ../start/: core_cm4.h core_cm4_simd.h startup_stm32f40_41xxx.s stm32f4xx.h stm32f4xx_conf.h system_stm32f4xx.c system_stm32f4xx.h
  group board
    ../board/: common.c common.h led.c led.h stm32f4xx_it.c stm32f4xx_it.h usart1.c usart1.h beep.c beep.h spi.c spi.h w25qxx.c w25qxx.h 24c02.c 24c02.h
  group driver
    ../driver/: misc.c misc.h stm32f4xx_adc.c stm32f4xx_adc.h stm32f4xx_can.c stm32f4xx_can.h stm32f4xx_crc.c stm32f4xx_crc.h stm32f4xx_cryp.c stm32f4xx_cryp.h stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dac.h stm32f4xx_dbgmcu.c stm32f4xx_dbgmcu.h stm32f4xx_dcmi.c stm32f4xx_dcmi.h stm32f4xx_dma.c stm32f4xx_dma.h stm32f4xx_dma2d.c stm32f4xx_dma2d.h stm32f4xx_exti.c stm32f4xx_exti.h stm32f4xx_flash.c stm32f4xx_flash.h stm32f4xx_flash_ramfunc.c stm32f4xx_flash_ramfunc.h stm32f4xx_fsmc.c stm32f4xx_fsmc.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_hash.c stm32f4xx_hash.h stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_i2c.h stm32f4xx_iwdg.c stm32f4xx_iwdg.h stm32f4xx_ltdc.c stm32f4xx_ltdc.h stm32f4xx_pwr.c stm32f4xx_pwr.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_rng.c stm32f4xx_rng.h stm32f4xx_rtc.c stm32f4xx_rtc.h stm32f4xx_sai.c stm32f4xx_sai.h stm32f4xx_sdio.c stm32f4xx_sdio.h stm32f4xx_spi.c stm32f4xx_spi.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h stm32f4xx_usart.c stm32f4xx_usart.h stm32f4xx_wwdg.c stm32f4xx_wwdg.h
  group device
    ../device/: dev_gpio.c blkdev_memblk.c blkdev_spi_flash.c blkdev_24c02.c dev_led.c list_blkdev.c list_dev.c dev_beep.c
  group port
    ../port/: wind_config.h wind_os_hwif.c wind_os_hwif.h wind_types.h wind_os_switch.s wind_std.c wind_std.h
  group common
    ../../../../../src/common/: wind_conv.c wind_conv.h wind_crc16.c wind_crc16.h wind_crc32.c wind_crc32.h wind_debug.c wind_debug.h wind_dlist.c wind_dlist.h wind_macro.h wind_queue.c wind_queue.h wind_string.c wind_string.h wind_tree.c wind_tree.h
  group console_framework
    ../../../../../src/console/framework/: console_framework.c console_framework.h wind_console.h wind_ctl_user.h wind_key.h cmd_history.c cmd_history.h
  group console_cmd
    ../../../../../src/console/cmd/: cmd_list.c cmd_echo.c cmd_datetime.c cmd_mem.c cmd_user.c cmd_stati.c cmd_reset.c cmd_led.c cmd_blkdev.c cmd_lua.c cmd_xmodem.c cmd_beep.c
  group console_port
    ../../../../../src/console/port/: console_port.c console_port.h
  group os_systhread
    ../../../../../src/systhread/: daemon_thread.c idle_thread.c init_thread.c stati_thread.c timer_thread.c
  group os_dev
    ../../../../../src/dev/: wind_dev.c wind_dev.h wind_blkdev.c wind_blkdev.h wind_file.c wind_file.h adapter_treefs.c
  group os_entry
    ../../../../../src/entry/IMT407z/: led_app.c user_entry.c
  group os_lib
    ../../../../../src/lib/: RBTree.c RBTree.h wind_stack.c wind_stack.h wind_atomic.c wind_atomic.h
  group os_xlib
    ../../../../../src/xlib/: fft.c fir.c firwin.c
  group os_core
    ../../../../../src/core/: wind_core.c wind_core.h wind_pipe.c wind_pipe.h wind_sem.c wind_sem.h wind_thread.c wind_thread.h wind_time.c wind_time.h wind_var.c wind_var.h wind_version.c wind_version.h wind_timer.c wind_timer.h wind_msgbox.c wind_msgbox.h wind_mutex.c wind_mutex.h wind_pool.c wind_pool.h wind_heap.c wind_heap.h wind_softirq.c wind_softirq.h
  group test_framwwork
    ../../../../../src/test/framework/: test_framework.c test_framework.h cmd_test.c wind_cut.h
  group test_port
    ../../../../../src/test/port/: test_port.c test_port.h
  group test_case
    ../../../../../src/test/testcase/: test_tree.c test_sem.c test_pipe.c test_queue.c test_msgbox.c test_mutex.c test_heap.c test_softirq.c test_pool.c
  group lua
    ../../../../../src/components/lua-5.3.4/src/: lapi.c lapi.h lauxlib.c lauxlib.h lbaselib.c lbitlib.c lcode.c lcode.h lcorolib.c lctype.c lctype.h ldblib.c ldebug.c ldebug.h ldo.c ldo.h ldump.c lfunc.c lfunc.h lgc.c lgc.h linit.c liolib.c llex.c llex.h llimits.h lmathlib.c lmem.c lmem.h loadlib.c lobject.c lobject.h lopcodes.c lopcodes.h loslib.c lparser.c lparser.h lprefix.h lstate.c lstate.h lstring.c lstring.h lstrlib.c ltable.c ltable.h ltablib.c ltm.c ltm.h lua.c lua.h luaconf.h lualib.h lundump.c lundump.h lutf8lib.c lvm.c lvm.h lzio.c lzio.h
    ../../../../../src/components/lua-5.3.4/port/: lua_port.c
  group fs_treefs
    ../../../../../src/fs/treefs/: treefs.c treefs.h
  group xmodem
    ../../../../../src/components/xmodem/: xmodem..c
